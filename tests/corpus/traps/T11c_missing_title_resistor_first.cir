R1 n1 0 2
V1 n1 0 6
.op
.end
