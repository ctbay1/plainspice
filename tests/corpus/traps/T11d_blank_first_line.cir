
V1 n1 0 6
R1 n1 0 2
.op
.end
